v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {vsource.sym} -60 -40 0 0 {name=V1 value=3 savecurrent=false}
C {vsource.sym} 40 -10 0 0 {name=V2 value=3 savecurrent=false}
